# Keil uVision project mpyrt1060.uvprojx, settings and files
target debug_sdram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: mpyrt_sdram
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_OMVRT1,__FPU_PRESENT=1,USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1,ARM_MATH_CM7,N_THUMB,NDEBUG,CPU_MIMXRT1052DVL6A,MCU_SERIES_RT106,USB_STACK_BM,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: --diag_suppress=1,39,61,66,68,111,546,188,1035,144,1211,1295,1296 --no_inline
  c include: ..\..\;..\..\py;..\..\extmod;..\..\lib;..\..\lib\cmsis\inc;..\nxp_rt1050_60;..\nxp_rt1050_60\boards\omvrt1;..\nxp_rt1050_60\mcusdk\;..\nxp_rt1050_60\mcusdk\drivers;..\nxp_rt1050_60\mcusdk\utilities;..\nxp_rt1050_60\cmsis;..\nxp_rt1050_60\build-omvrt1;..\nxp_rt1050_60\usb_cdc_msc;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\include;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\osa;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\device;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\phy;..\nxp_rt1050_60\sdmmc;..\nxp_rt1050_60\omv;..\nxp_rt1050_60\omv\py;..\nxp_rt1050_60\omv\img;..\nxp_rt1050_60\omv\nn;..\..\lib\oofatfs;..\..\lib\mp-readline
  asm define: USE_OCRAM=1
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\sdram_ocram.sct
  link misc: --any_placement=next_fit --keep=*.o(.boot*)
  group cmsis_dsp_nn
    ../../lib/cmsis/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../lib/cmsis/dsp/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ../../lib/cmsis/dsp/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ../../lib/cmsis/nn/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c
    ../../lib/cmsis/nn/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
    ../../lib/cmsis/nn/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c
    ../../lib/cmsis/nn/NNSupportFunctions/: arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
    ../../lib/cmsis/nn/PoolingFunctions/: arm_pool_q7_HWC.c
    ../../lib/cmsis/nn/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c
  group prebuilt
    ./: mpynxp_rt1050_60.lib
  group py
    ../../py/: argcheck.c asmbase.c asmthumb.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitnative.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpz.c nativeglue.c nlrsetjmp.c nlrthumb.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c qstr.c reader.c repl.c runtime.c runtime_utils.c scheduler.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c asmbase.h asmthumb.h bc.h bc0.h binary.h builtin.h compile.h emit.h emitglue.h formatfloat.h frozenmod.h gc.h grammar.h lexer.h misc.h mpconfig.h mperrno.h mphal.h mpprint.h mpstate.h mpthread.h mpz.h nlr.h obj.h objarray.h objexcept.h objfun.h objgenerator.h objint.h objlist.h objmodule.h objstr.h objstringio.h objtuple.h objtype.h parse.h parsenum.h parsenumbase.h persistentcode.h qstr.h qstrdefs.h reader.h repl.h ringbuf.h runtime.h runtime0.h scope.h smallint.h stackctrl.h stream.h unicode.h vmentrytable.h asmarm.c asmx64.c asmx86.c asmxtensa.c nlrx64.c nlrx86.c nlrxtensa.c
  group lib_libc
    ../../lib/libc/: string0.c
  group lib_libm
    ../../lib/libm/: acoshf.c asinfacosf.c asinhf.c atan2f.c atanf.c atanhf.c ef_rem_pio2.c ef_sqrt.c erf_lgamma.c fmodf.c kf_cos.c kf_rem_pio2.c kf_sin.c kf_tan.c log1pf.c math.c nearbyintf.c roundf.c sf_cos.c sf_erf.c sf_frexp.c sf_ldexp.c sf_modf.c sf_sin.c sf_tan.c thumb_vfp_sqrtf.c wf_lgamma.c wf_tgamma.c fdlibm.h libm.h
  group lib_misc
    ../../lib/oofatfs/: ff.c ff.h diskio.h ffconf.h
    ../../lib/oofatfs/option/: ccsbcs.c unicode.c
    ../../lib/mp-readline/: readline.c
    ../../lib/netutils/: netutils.c netutils.h
    ../../lib/timeutils/: timeutils.c timeutils.h
    ../../lib/utils/: interrupt_char.c pyexec.c printf.c interrupt_char.h pyexec.h
  group extmod
    ../../extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modubinascii.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_fat_misc.c vfs_reader.c virtpin.c
  group mcusdk
    ../nxp_rt1050_60/mcusdk/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpi2c_freertos.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpspi_freertos.c fsl_lpuart.c fsl_lpuart_edma.c fsl_lpuart_freertos.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c fsl_csi_camera_adapter.c
  group mcusdk_utils
    ../nxp_rt1050_60/mcusdk/utilities/: fsl_debug_console.c fsl_assert.c fsl_shell.c
    ../nxp_rt1050_60/mcusdk/utilities/log/: fsl_log.c
    ../nxp_rt1050_60/mcusdk/utilities/str/: fsl_str.c
    ../nxp_rt1050_60/mcusdk/utilities/io/: fsl_io.c
  group mcusdkRT1062
    ../nxp_rt1050_60/mcusdkRT1062/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpi2c_freertos.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpspi_freertos.c fsl_lpuart.c fsl_lpuart_edma.c fsl_lpuart_freertos.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c fsl_csi_camera_adapter.c
  group mcusdk_utilsRT1062
    ../nxp_rt1050_60/mcusdkRT1062/utilities/: fsl_debug_console.c fsl_assert.c fsl_shell.c
    ../nxp_rt1050_60/mcusdkRT1062/utilities/log/: fsl_log.c
    ../nxp_rt1050_60/mcusdkRT1062/utilities/str/: fsl_str.c
    ../nxp_rt1050_60/mcusdkRT1062/utilities/io/: fsl_io.c
  group build_evk
    ../nxp_rt1050_60/build-imxrtevk105x/: frozen_mpy.c pins_imxrtevk105x.c pins_qstr.h modmcu_qstr.h
    ../nxp_rt1050_60/build-imxrtevk105x/genhdr/: modmcu_const.h qstrdefs.generated.h
  group build_omvrt1
    ../nxp_rt1050_60/build-omvrt1/: frozen_mpy.c pins_omvrt1.c pins_qstr.h modmcu_qstr.h
    ../nxp_rt1050_60/build-omvrt1/genhdr/: modmcu_const.h qstrdefs.generated.h
  group port
    ../nxp_rt1050_60/: startup_MIMXRT1052.s gchelper_armccv5.S isr.c bufhelper.c dma.c adc.c dcmc.c extint.c fatfs_port.c flash.c gccollect.c help.c irq.c led.c main.c main_omv.c modmachine.c modnetwork.c modpyb.c modmcu.c moduos.c modusocket.c modutime.c mphalport.c mpthreadport.c pendsv.c pin.c pin_named_pins.c pybstdio.c pybthread.c rng.c rtc.c sdcard.c servo.c i2c.c pwm.c qtimer.c rpm.c srpm.c spi.c storage.c systick.c tmr.c uart.c uniqueID.c usb_app.c usbd_conf.c usbd_desc.c usbd_hid_interface.c usbd_msc_storage.c usrsw.c wdt.c accel.h adc.h bufhelper.h can.h dac.h dcmc.h dma.h extint.h flash.h font_petme128_8x8.h gccollect.h i2c.h irq.h lcd.h led.h makeout.txt modmachine.h modnetwork.h mpconfigport.h mphalport.h mpthreadport.h pendsv.h pin.h pin_defs_nxp_rt1050_60.h portmodules.h pybthread.h qstrdefsport.h qtimer.h rng.h rpm.h rtc.h sdcard.h servo.h spi.h storage.h systick.h timer.h uart.h unistd.h usb_app.h usbd_cdc_interface.h usbd_conf.h usbd_desc.h usbd_hid_interface.h usbd_msc_storage.h usrsw.h wdt.h hal_wrapper.c hal_wrapper.h pin_defs_mcu.c pin_defs_mcu.h flash_hyper.c overlay_manager.c overlay_manager.h flash_pgm.c
    ../nxp_rt1050_60/mcusdk/: system_MIMXRT1052.c
    ../nxp_rt1050_60/mcusdkRT1062/: system_MIMXRT1052.c
  group Board
    ../nxp_rt1050_60/boards/omvrt1/: board.c clock_config.c pin_mux.c board.h clock_config.h pin_mux.h
  group sdk_usb
    ../nxp_rt1050_60/mcusdk/middleware/sdkusb/device/: usb_device_dci.c usb_device_ehci.c
    ../nxp_rt1050_60/mcusdk/middleware/sdkusb/osa/: usb_osa_bm.c
    ../nxp_rt1050_60/usb_cdc_msc/: composite.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_class.c usb_device_descriptor.c usb_device_msc.c usb_device_msc_ufi.c virtual_com.c ring_buffer.c
    ../nxp_rt1050_60/mcusdk/middleware/sdkusb/phy/: usb_phy.c
    ../nxp_rt1050_60/mcusdkRT1062/middleware/sdkusb/device/: usb_device_dci.c usb_device_ehci.c
    ../nxp_rt1050_60/mcusdkRT1062/middleware/sdkusb/osa/: usb_osa_bm.c
    ../nxp_rt1050_60/mcusdkRT1062/middleware/sdkusb/phy/: usb_phy.c
  group sdk_usb_headers
    ../nxp_rt1050_60/mcusdk/middleware/sdkusb/osa/: usb_osa_bm.h usb_osa.h
    ../nxp_rt1050_60/mcusdk/middleware/sdkusb/device/: usb_device_dci.h usb_device.h usb_device_ehci.h
    ../nxp_rt1050_60/mcusdk/middleware/sdkusb/include/: usb_spec.h usb_misc.h
    ../nxp_rt1050_60/usb_cdc_msc/: composite.h usb_device_cdc_acm.h usb_device_ch9.h usb_device_class.h usb_device_config.h usb_device_descriptor.h usb_device_msc.h usb_device_msc_ufi.h virtual_com.h ring_buffer.h
  group sdmmc
    ../nxp_rt1050_60/sdmmc/: fsl_mmc.c fsl_sd.c fsl_sdspi.c fsl_sdmmc_common.c
    ../nxp_rt1050_60/sdmmc/port_usdhc_irq/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group nxp_swim
    ../nxp_rt1050_60/nxp_swim/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_rom8x16.c lpc_rom8x8.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_swim_image_mono.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c py_swim.c
    ../nxp_rt1050_60/nxp_swim/drivers/: lpc_oled_driver.c
    ../nxp_rt1050_60/nxp_swim/inc/: lpc_colors.h lpc_fonts.h lpc_helvr10.h lpc_rom8x16.h lpc_rom8x8.h lpc_swim.h lpc_swim_font.h lpc_swim_image.h lpc_winfreesystem14x16.h lpc_x5x7.h lpc_x6x13.h
    ../nxp_rt1050_60/: oled_128128.c
  group ay_imu
    ../nxp_rt1050_60/ay_imu/core/: fusion.c integration.c madgwick_fusion.c mahony_fusion.c state_detect.c fusion.h integration.h madgwick_fusion.h mahony_fusion.h state_detect.h
    ../nxp_rt1050_60/ay_imu/math/: dcm.c eular.c fitting.c math_helper.c numerical_integration.c quaternion.c vector.c dcm.h eular.h fitting.h math_helper.h numerical_integration.h quaternion.h vector.h
    ../nxp_rt1050_60/ay_imu/: py_imu.c
  group flexspi_xip
    ../nxp_rt1050_60/mcusdk/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h fsl_flexspi_nor_flash.c fsl_flexspi_nor_flash.h
    ../nxp_rt1050_60/mcusdkRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h fsl_flexspi_nor_flash.c fsl_flexspi_nor_flash.h
  group fleg_ftl
    ../nxp_rt1050_60/flegftl/: flegftl.c
  group omv_mini
    ../nxp_rt1050_60/omv/: cambus.c mt9v034.c mutex.c ov2640.c ov7725.c ov9650.c sensor.c xalloc.c usbdbg.c framebuffer.c array.c fb_alloc.c ff_wrapper.c ini.c sdram.c umm_malloc.c
  group lib_readline
    ../../lib/mp-readline/: readline.c
  group omv_py
    ../nxp_rt1050_60/omv/py/: py_cpufreq.c py_fir.c py_gif.c py_image.c py_lcd_omvrt1.c py_mjpeg.c py_winc.c py_omv.c py_nn.c py_tv.c
  group omv_img_mini
    ../nxp_rt1050_60/omv/img/: rgb2rgb_tab.c fmath.c yuv_tab.c jpeg.c
    ../nxp_rt1050_60/omv/py/: py_helper.c py_time.c py_sensor.c
    ../nxp_rt1050_60/boards/omvrt1/: omv_boardconfig.h
    ../../lib/: cmsis_nn_iar_lib.lib
  group omv_img_en
    ../nxp_rt1050_60/omv/img/: agast.c apriltag.c blob.c bmp.c collections.c dmtx.c edge.c eye.c fast.c fft.c font.c fsort.c gif.c haar.c hog.c hough.c imlib.c integral.c integral_mw.c invariant_tab.c kmeans.c lab_tab.c lbp.c lsd.c mjpeg.c orb.c phasecorrelation.c point.c pool.c ppm.c qrcode.c rainbow_tab.c rectangle.c selective_search.c shadow_removal.c sincos_tab.c stats.c template.c xyz_tab.c zbar.c binary.c clahe.c draw.c filter.c line.c mathop.c qsort.c
    ../nxp_rt1050_60/omv/nn/: nn.c
  group omv_wifi_dbg
    ../../drivers/m8266/: m8266_hw.c socket_m8266.c winc.c
    ../../drivers/m8266/lib_new/: M8266WIFIDrv_iMXRT10xx.a
    ../nxp_rt1050_60/omv/: wifidbg.c
    ../../drivers/m8266/lib/: M8266WIFIDrv_iMXRT10xx.lib
target debug_flexspi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.11.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: mpyrt_flexspi
  AfterMake: fromelf --bincombined --output=omvrt.bin #L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_OMVRT1,__FPU_PRESENT=1,USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1,ARM_MATH_CM7,N_THUMB,NDEBUG,CPU_MIMXRT1052DVL6A,MCU_SERIES_RT105,MCU_SERIES_RT106,USB_STACK_BM,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1,XIP_EXTERNAL_FLASH
  c misc: as above
  c include: ..\..\;..\..\py;..\..\extmod;..\..\lib;..\..\lib\cmsis\inc;..\nxp_rt1050_60;..\nxp_rt1050_60\boards\omvrt1;..\nxp_rt1050_60\mcusdk\;..\nxp_rt1050_60\mcusdk\drivers;..\nxp_rt1050_60\mcusdk\utilities;..\nxp_rt1050_60\cmsis;..\nxp_rt1050_60\build-omvrt1;..\nxp_rt1050_60\usb_cdc_msc;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\include;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\osa;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\device;..\nxp_rt1050_60\mcusdk\middleware\sdkusb\phy;..\nxp_rt1050_60\sdmmc;..\nxp_rt1050_60\omv;..\nxp_rt1050_60\omv\py;..\nxp_rt1050_60\omv\img;..\nxp_rt1050_60\omv\nn;..\..\lib\oofatfs;..\..\lib\mp-readline;..\..\drivers\m8266;..\..\drivers\m8266\lib_new
  asm define: XIP_EXTERNAL_FLASH
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Flh+RAM_1060.sct
  link misc: --any_placement=next_fit --keep=*.o(.boot*) --emit_debug_overlay_relocs --emit_debug_overlay_section
target debug_ocram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.3
  cpu: as above
  output: mpyrt_flexspi_ocram
  AfterMake: fromelf --bincombined --output=omvrt.bin #L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT=1,USE_OCRAM=1,USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1,ARM_MATH_CM7,N_THUMB,NDEBUG,CPU_MIMXRT1052DVL6A,MCU_SERIES_RT105,USB_STACK_BM,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1,XIP_EXTERNAL_FLASH
  c misc: as above
  c include: as above
  asm define: XIP_EXTERNAL_FLASH, USE_OCRAM=1
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Flh+RAM_ocram.sct
  link misc: as above
target debug_flexspi_wifidbg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1062CVL5A NXP
  pack: NXP.MIMXRT1062_DFP.11.0.1
  cpu: as above
  output: mpyrt_flexspi
  AfterMake: fromelf --bincombined --output=omvrt.bin #L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_OMVRT1,__FPU_PRESENT=1,USB_DEVICE_CONFIG_BUFFER_PROPERTY_CACHEABLE=1,ARM_MATH_CM7,N_THUMB,NDEBUG,CPU_MIMXRT1052DVL6A,MCU_SERIES_RT106,USB_STACK_BM,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1,XIP_EXTERNAL_FLASH,MICROPY_HW_WIFIDBG_EN=1
  c misc: as above
  c include: ..\..\;..\..\py;..\..\extmod;..\..\lib;..\..\lib\cmsis\inc;..\nxp_rt1050_60;..\nxp_rt1050_60\boards\omvrt1;..\nxp_rt1050_60\mcusdkRT1062\;..\nxp_rt1050_60\mcusdkRT1062\drivers;..\nxp_rt1050_60\mcusdkRT1062\utilities;..\nxp_rt1050_60\mcusdkRT1062\utilities\io;..\nxp_rt1050_60\cmsis;..\nxp_rt1050_60\build-omvrt1;..\nxp_rt1050_60\usb_cdc_msc;..\nxp_rt1050_60\mcusdkRT1062\middleware\sdkusb\include;..\nxp_rt1050_60\mcusdkRT1062\middleware\sdkusb\osa;..\nxp_rt1050_60\mcusdkRT1062\middleware\sdkusb\device;..\nxp_rt1050_60\mcusdkRT1062\middleware\sdkusb\phy;..\nxp_rt1050_60\sdmmc;..\nxp_rt1050_60\omv;..\nxp_rt1050_60\omv\py;..\nxp_rt1050_60\omv\img;..\nxp_rt1050_60\omv\nn;..\..\lib\oofatfs;..\..\lib\mp-readline;..\..\drivers\m8266;..\..\drivers\m8266\lib;..\nxp_rt1050_60\mcusdkRT1062\utilities\log;..\nxp_rt1050_60\mcusdkRT1062\utilities\str
  asm define: XIP_EXTERNAL_FLASH
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Flh+RAM_1060.sct
  link misc: as above
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0

# Keil uVision project mpyrt105.uvprojx, settings and files
target debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: mpynxp_rt105
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N_THUMB,NDEBUG,CPU_MIMXRT1052DVL6A,MCU_SERIES_RT105,USB_STACK_BM,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP
  c misc: --gnu --diag_suppress=1,39,61,66,68,111,546,188,1035,144,1211,1295,1296 --no_inline
  c include: ..\..\;..\..\py;..\..\extmod;..\..\lib;..\..\lib\cmsis\inc;..\nxp_rt105;..\nxp_rt105\boards\imxrtevk105x;..\nxp_rt105\mcusdk\;..\nxp_rt105\mcusdk\drivers;..\nxp_rt105\mcusdk\utilities;..\nxp_rt105\cmsis;..\nxp_rt105\build-imxrtevk105x;..\nxp_rt105\usb_cdc_msc;..\nxp_rt105\mcusdk\middleware\sdkusb\include;..\nxp_rt105\mcusdk\middleware\sdkusb\osa;..\nxp_rt105\mcusdk\middleware\sdkusb\device;..\nxp_rt105\sdmmc
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\flash.sct
  link misc: --any_placement=next_fit
  group prebuilt
    ./: mpynxp_rt105.lib
  group py
    ../../py/: argcheck.c asmbase.c asmthumb.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitnative.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpz.c nativeglue.c nlrsetjmp.c nlrthumb.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c qstr.c reader.c repl.c runtime.c runtime_utils.c scheduler.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c asmbase.h asmthumb.h bc.h bc0.h binary.h builtin.h compile.h emit.h emitglue.h formatfloat.h frozenmod.h gc.h grammar.h lexer.h misc.h mpconfig.h mperrno.h mphal.h mpprint.h mpstate.h mpthread.h mpz.h nlr.h obj.h objarray.h objexcept.h objfun.h objgenerator.h objint.h objlist.h objmodule.h objstr.h objstringio.h objtuple.h objtype.h parse.h parsenum.h parsenumbase.h persistentcode.h qstr.h qstrdefs.h reader.h repl.h ringbuf.h runtime.h runtime0.h scope.h smallint.h stackctrl.h stream.h unicode.h vmentrytable.h asmarm.c asmx64.c asmx86.c asmxtensa.c nlrx64.c nlrx86.c nlrxtensa.c
  group lib_libc
    ../../lib/libc/: string0.c
  group lib_libm
    ../../lib/libm/: acoshf.c asinfacosf.c asinhf.c atan2f.c atanf.c atanhf.c ef_rem_pio2.c ef_sqrt.c erf_lgamma.c fmodf.c kf_cos.c kf_rem_pio2.c kf_sin.c kf_tan.c log1pf.c math.c nearbyintf.c roundf.c sf_cos.c sf_erf.c sf_frexp.c sf_ldexp.c sf_modf.c sf_sin.c sf_tan.c thumb_vfp_sqrtf.c wf_lgamma.c wf_tgamma.c fdlibm.h libm.h
  group lib_misc
    ../../lib/oofatfs/: ff.c ff.h diskio.h ffconf.h
    ../../lib/oofatfs/option/: ccsbcs.c unicode.c
    ../../lib/mp-readline/: readline.c
    ../../lib/netutils/: netutils.c netutils.h
    ../../lib/timeutils/: timeutils.c timeutils.h
    ../../lib/utils/: interrupt_char.c pyexec.c printf.c interrupt_char.h pyexec.h
  group extmod
    ../../extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modubinascii.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_fat_misc.c vfs_reader.c virtpin.c
  group mcusdk
    ../nxp_rt105/mcusdk/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpi2c_freertos.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpspi_freertos.c fsl_lpuart.c fsl_lpuart_edma.c fsl_lpuart_freertos.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
  group build_lpx546
    ../nxp_rt105/build-imxrtevk105x/: frozen_mpy.c pins_imxrtevk105x.c pins_qstr.h modmcu_qstr.h
    ../nxp_rt105/build-imxrtevk105x/genhdr/: modmcu_const.h
  group port
    ../nxp_rt105/: startup_MIMXRT1052.s gchelper_armccv5.S isr.c bufhelper.c dma.c extint.c fatfs_port.c flash.c gccollect.c help.c irq.c led.c main.c modmachine.c modnetwork.c modpyb.c modmcu.c moduos.c modusocket.c modutime.c mphalport.c mpthreadport.c pendsv.c pin.c pin_named_pins.c pybstdio.c pybthread.c rng.c rtc.c sdcard.c servo.c i2c.c spi.c storage.c systick.c timer.c uart.c usb_app.c usbd_conf.c usbd_desc.c usbd_hid_interface.c usbd_msc_storage.c usrsw.c wdt.c startup_stm32.S startup_stm32f405xx.S accel.h adc.h bufhelper.h can.h dac.h dma.h extint.h flash.h font_petme128_8x8.h gccollect.h i2c.h irq.h lcd.h led.h makeout.txt modmachine.h modnetwork.h mpconfigport.h mphalport.h mpthreadport.h pendsv.h pin.h pin_defs_nxp_rt105.h portmodules.h pybthread.h qstrdefsport.h rng.h rtc.h sdcard.h servo.h spi.h stm32_it.h storage.h systick.h timer.h uart.h unistd.h usb_app.h usbd_cdc_interface.h usbd_conf.h usbd_desc.h usbd_hid_interface.h usbd_msc_storage.h usrsw.h wdt.h hal_wrapper.c hal_wrapper.h pin_defs_lpc546.c pin_defs_lpc546.h
  group Board
    ../nxp_rt105/boards/imxrtevk105x/: board.c clock_config.c pin_mux.c board.h clock_config.h pin_mux.h
  group sdk_usb
    ../nxp_rt105/mcusdk/middleware/sdkusb/device/: usb_device_dci.c usb_device_ehci.c
    ../nxp_rt105/mcusdk/middleware/sdkusb/osa/: usb_osa_bm.c
    ../nxp_rt105/usb_cdc_msc/: composite.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_class.c usb_device_descriptor.c usb_device_msc.c usb_device_msc_ufi.c virtual_com.c ring_buffer.c
  group sdk_usb_headers
    ../nxp_rt105/mcusdk/middleware/sdkusb/osa/: usb_osa_bm.h usb_osa.h
    ../nxp_rt105/mcusdk/middleware/sdkusb/device/: usb_device_dci.h usb_device.h usb_device_ehci.h
    ../nxp_rt105/mcusdk/middleware/sdkusb/include/: usb_spec.h usb_misc.h
    ../nxp_rt105/usb_cdc_msc/: composite.h usb_device_cdc_acm.h usb_device_ch9.h usb_device_class.h usb_device_config.h usb_device_descriptor.h usb_device_msc.h usb_device_msc_ufi.h virtual_com.h ring_buffer.h
  group sdmmc
    ../nxp_rt105/sdmmc/: fsl_mmc.c fsl_sd.c fsl_sdmmc.c fsl_sdspi.c port_event_irq.c port_host_irq.c
  group nxp_swim
    ../nxp_rt105/nxp_swim/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_rom8x16.c lpc_rom8x8.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_swim_image_mono.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c py_swim.c
    ../nxp_rt105/nxp_swim/drivers/: lpc_oled_driver.c
    ../nxp_rt105/nxp_swim/inc/: lpc_colors.h lpc_fonts.h lpc_helvr10.h lpc_rom8x16.h lpc_rom8x8.h lpc_swim.h lpc_swim_font.h lpc_swim_image.h lpc_winfreesystem14x16.h lpc_x5x7.h lpc_x6x13.h
    ../nxp_rt105/: oled_128128.c
  group ay_imu
    ../nxp_rt105/ay_imu/core/: fusion.c integration.c madgwick_fusion.c mahony_fusion.c state_detect.c fusion.h integration.h madgwick_fusion.h mahony_fusion.h state_detect.h
    ../nxp_rt105/ay_imu/math/: dcm.c eular.c fitting.c math_helper.c numerical_integration.c quaternion.c vector.c dcm.h eular.h fitting.h math_helper.h numerical_integration.h quaternion.h vector.h
    ../nxp_rt105/ay_imu/: py_imu.c
target lib_py (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54608J512BD208 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x028000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x080000) XRAM(0x40100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpynxp_rt105 (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N_THUMB,NDEBUG,CPU_LPC54608J512BD208,MCU_SERIES_LPC546,USB_STACK_BM,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP
  c misc: --gnu --diag_suppress=1,39,61,66,68,111,546,188,1035,144,1211,1295 --no_inline
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\flash.sct
  link misc: --any_placement=next_fit
target IFlash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpynxp_rt105
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N_THUMB,NDEBUG,CPU_LPC54608J512BD208,MCU_SERIES_LPC546,STM32_HAL_H='<stm32f4xx_hal.h>',__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,MICROPY_QSTR_EXTRA_POOL=mp_qstr_frozen_const_pool,MICROPY_MODULE_FROZEN_MPY,FFCONF_H='\"oofatfs/ffconf.h\"',HARD_FP
  c misc: --gnu --diag_suppress=61,68,111,546,188,1035,144,1211,1295 --no_inline
  c include: ..\..\;..\..\py;..\..\extmod;..\..\lib;..\..\lib\cmsis\inc;..\nxp_rt105;..\nxp_rt105\boards\imxrtevk105x;..\nxp_rt105\mcusdk\;..\nxp_rt105\mcusdk\drivers;..\nxp_rt105\mcusdk\utilities;..\nxp_rt105\cmsis;..\nxp_rt105\build-imxrtevk105x;..\nxp_rt105\usbdev\core\inc;..\nxp_rt105\usbdev\class\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\flash.sct
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
